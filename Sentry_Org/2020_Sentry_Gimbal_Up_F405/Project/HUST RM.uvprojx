# Keil uVision project HUST RM.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HUST RM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx, MATH_CM4,__FPU_PRESENT=1,__FPU_USED =1, ARM_MATH_CM4, __CC_ARM
  c include: ..\Library\CMSIS;..\Library\inc;..\Algo\algo_inc;..\Hardware\bsp\bsp_inc;..\Hardware\dev\dev_inc;..\User;..\Task\task_inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c system_stm32f4xx.c main.c main.h
  group bsp
    ../Hardware/bsp/bsp_src/: bsp_CAN.c bsp_USART2_PC.c bsp_USART3_RC.c bsp_TIM4_pwm.c bsp_TIM2_delay.c bsp_GPIO_LED.c
  group Task
    ../Task/task_src/: task_StateLED.c task_ActionUpdate.c task_DataReceive.c task_DataSend.c task_GimbalUp.c task_Shoot.c task_ZeroCheck.c
  group Library
    ../Library/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_syscfg.c
    ../Library/CMSIS/: startup_stm32f40_41xxx.s
  group Dev
    ../Hardware/dev/dev_src/: dev_DBUS.c dev_FrictionWheel.c
  group Algo
    ../Algo/algo_src/: algo_PID.c algo_CRC.c algo_ADT_LoopQueue.c algo_FIR.c
  group inc
    ../Algo/algo_inc/: algo_CRC.h algo_PID.h
    ../Hardware/bsp/bsp_inc/: bsp_CAN.h bsp_UART4.h bsp_USART2_PC.h bsp_USART3_RC.h bsp_TIM4_pwm.h bsp_TIM2_delay.h bsp_GPIO_LED.h
    ../Hardware/dev/dev_inc/: dev_DBUS.h dev_FrictionWheel.h
    ../Task/task_inc/: task_ActionUpdate.h task_Chassis.h task_DataReceive.h task_DataSend.h task_GimbalUp.h task_Shoot.h task_ZeroCheck.h task_StateLED.h
