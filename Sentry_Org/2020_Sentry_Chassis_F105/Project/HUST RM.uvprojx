# Keil uVision project HUST RM.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HUST RM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\Library\CMSIS;..\Library\inc;..\Library\src;..\Algo\algo_inc;..\Hardware\bsp\bsp_inc;..\Hardware\dev\dev_inc;..\Task\task_inc;..\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: stm32f10x_it.c system_stm32f10x.c main.c main.h
  group bsp
    ../Hardware/bsp/bsp_src/: bsp_CAN.c bsp_EXTI.c bsp_USART1_Judge.c bsp_TIM2_timer.c bsp_TIM3_encoder.c bsp_GPIO_photoelectric_switch.c
  group Task
    ../Task/task_src/: task_Chassis.c task_DataReceive.c task_DataSend.c task_ZeroCheck.c task_Shoot_Up.c
  group Library
    ../Library/src/: misc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
    ../Library/CMSIS/: startup_stm32f10x_cl.s
  group Dev
    ../Hardware/dev/dev_src/: dev_Encoder.c dev_IIC.c dev_INA260.c dev_PhotoelectricSwitch.c dev_LED.c dev_LimitSwitch.c
  group Algo
    ../Algo/algo_src/: algo_CRC.c algo_PID.c
  group inc
    ../Algo/algo_inc/: algo_CRC.h algo_PID.h
    ../Hardware/bsp/bsp_inc/: bsp_CAN.h bsp_EXTI.h bsp_UART4.h bsp_USART1_Judge.h bsp_USART2.h bsp_TIM2_timer.h bsp_TIM3_encoder.h bsp_GPIO_limit_switch.h bsp_GPIO_photoelectric_switch.h
    ../Hardware/dev/dev_inc/: dev_Encoder.h dev_IIC.h dev_PhotoelectricSwitch.h dev_INA260.h dev_LED.h dev_LimitSwitch.h
    ../Task/task_inc/: task_Chassis.h task_DataReceive.h task_DataSend.h task_ZeroCheck.h task_Shoot_Up.h
