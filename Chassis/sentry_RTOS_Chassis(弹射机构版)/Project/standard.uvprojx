# Keil uVision project standard.uvprojx, settings and files
target standard (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sentry_Chassis +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB\inc;..\User;..\FreeRTOS\include;..\FreeRTOS\portable;..\hardware;..\tasks;..\algo;..\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f10x_cl.s
  group CMSIS
    ../CMSIS/: system_stm32f10x.c stm32f10x_it.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group main
    ../user/: main.c main.h
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group task
    ../tasks/: start_task.c task_ActionUpdate.c task_StateLED.c task_BlockDisconnect.c task_Chassis.c taskIT_DataReceive.c task_ZeroCheck.c task_DataSend.c task_PowerReadINA.c task_PhotoEleSwRead.c task_LimitSwRead.c task_UsageCPU.c task_JudgeDecode.c
  group freeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group hardware
    ../hardware/: HW_CAN.c HW_Encoder.c HW_TIM_EncoderZ.c HW_INA260.c HW_LED.c HW_LimitSwitch.c HW_PhotoelectricSwitch.c HW_TIM3_Encoder.c HWbsp_IIC.c HW_DBUS.c HW_TIM2_delay.c HW_TIM5_runtimeCPU.c HW_USART1_debugPC.c HW_IWDG.c HW_USART2_judge.c HW_Judgement_Decode.c HW_ADC.c usart3_remote.c
  group algo
    ../algo/: algo_CRC.c algo_HeatControl.c algo_PID.c
