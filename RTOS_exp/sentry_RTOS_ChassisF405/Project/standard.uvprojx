# Keil uVision project standard.uvprojx, settings and files
target standard (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sentry_Chassis_F405 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\User;..\FreeRTOS\include;..\FreeRTOS\portable;..\hardware;..\tasks;..\algo;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\DSP\Include;..\user\user_math_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c stm32f4xx_it.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group main
    ../user/: main.c main.h
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group task
    ../tasks/: start_task.c task_ActionUpdate.c task_StateLED.c task_BlockDisconnect.c task_Chassis.c taskIT_DataReceive.c task_ZeroCheck.c task_DataSend.c task_PowerReadINA.c task_PhotoEleSwRead.c task_UsageCPU.c task_JudgeDecode.c
  group freeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group hardware
    ../hardware/: HW_CAN.c HW_Encoder.c HW_EXTI_EncoderZ.c HW_INA260.c HW_LED.c HW_LimitSwitch.c HW_PhotoelectricSwitch.c HW_TIM3_Encoder.c HWbsp_IIC.c HW_DBUS.c HW_TIM2_delay.c HW_TIM5_runtimeCPU.c HW_USART1_debugPC.c HW_IWDG.c HW_Judgement_Decode.c
  group algo
    ../algo/: algo_CRC.c algo_PID.c
  group user_lib
    ../user/user_math_lib/: user_lib.c
